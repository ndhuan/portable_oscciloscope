# Keil uVision project portable_osc.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.6.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: portable_osc
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32746G_DISCO,USE_IOEXPANDER,USE_USB_HS,HSE_VALUE=25000000
  c include: ..\Inc;..\Drivers\BSP\Components\Common;..\Drivers\CMSIS\Include;..\Drivers\STM32F7xx_HAL_Driver\Inc;..\Drivers\BSP\STM32746G-Discovery;..\Utilities\Fonts;..\Middlewares\FatFs\src;..\Middlewares\FatFs\src\drivers;..\Middlewares\STM32_USB_Host_Library\Core\Inc;..\Middlewares\STM32_USB_Host_Library\Class\MSC\Inc;..\Drivers\BSP\Components\mfxstm32l152;..\Drivers\BSP\Components\stmpe811;..\Drivers\BSP\Components\exc7200;..\Drivers\BSP\Components\ts3510;..\Drivers\BSP\Components\Common;..\EmWi_GUI\BoardConfig;..\EmWi_GUI\Misc;..\EmWi_GUI\PlatformPackage\RGBA8888\GFX;..\EmWi_GUI\STM32Fx;..\EmWi_GUI\PlatformPackage\RTE
  asm include: ..\Inc;..\Drivers\CMSIS\Include;..\Drivers\STM32F7xx_HAL_Driver\Inc;..\Drivers\BSP\STM32746G-Discovery;..\Drivers\BSP\Components\Common;..\Utilities\Fonts
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group User
    ../Src/: main.c stm32f7xx_it.c ts_calibration.c stm32f7xx_hal_msp.c timer.c
    ../src/: uart.c my_int_handler.c adc.c pwm.c
  group MDK-ARM
    ../Drivers/CMSIS/Device/: startup_stm32f746xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_ll_fmc.c stm32f7xx_hal_hcd.c stm32f7xx_hal_pwr_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_ll_usb.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c
  group Drivers/BSP/STM32F746_Discovery
    ../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/ft5336/: ft5336.c
    ../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group FatFs/Drivers
    ../Middlewares/FatFs/src/drivers/: usbh_diskio.c
  group FatFs/Core
    ../Middlewares/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group STM32_USBH_Library/Core
    ../Middlewares/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group STM32_USBH_Library/Class/MSC
    ../Middlewares/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group UI
    ../Src/: UI.c
  group USB
    ../Src/: usbh_conf.c my_usbh.c
  group UI/Misc
    ../EmWi_GUI/Misc/: tlsf.c xprintf.c
  group UI/BoardConfig
    ../EmWi_GUI/BoardConfig/: BoardConfig.c
  group UI/PlatformPackage
    ../EmWi_GUI/PlatformPackage/RGBA8888/GFX/: ewextgfx.c libewgfx-eval.a libewgfx-eval-mu.a
    ../EmWi_GUI/PlatformPackage/RTE/: ewextrte.c libewrte.a libewrte-mu.a
  group UI/STM32Fx
    ../EmWi_GUI/STM32Fx/: Application.c Charts.c Core.c Effects.c Flat.c Graphics.c Resources.c Steel.c Views.c XFlat.c
software components: CMSIS:CORE 5.0.0
